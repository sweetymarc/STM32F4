# Keil uVision project Project.uvproj, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\\Drivers_new\BSP\Components\ov7725;..\..\..\..\Middlewares_new\JPEG_ENCODE;..\..\..\..\Drivers_new\BSP\Components\nrf24l01p;..\..\..\..\\Drivers_new\BSP\STM32F429IGT6_ShenZhouWang;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\Drivers\BSP\STM32F4-Discovery;..\..\..\..\Drivers_new\BSP\Components\mavlink;..\..\..\..\Drivers_new\BSP\STM32F4;..\..\..\..\Middlewares_new\websocket
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers_new/BSP/Components/nrf24l01p/: hal_nrf.c hal_nrf_hw.c
    ../../../../Drivers_new/BSP/Components/ov7725/: OV7725.c
  group Drivers/BSP/STM32F407
    ../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_sd.c
    ../../../../Drivers_new/BSP/STM32F429IGT6_ShenZhouWang/: stm32f429_camera.c
    ../../../../Drivers_new/BSP/STM32F4/: stm32f4_nrf.c stm32f4_printf.c stm32f4_sonar.c stm32f4_uSD.c stm32f4_esp8266.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_sdmmc.c
  group Example/MDK-ARM
    ./: startup_stm32f407xx.s
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c JPEG_ENCODE.c pwm.c mavlink.c matrix.c vision_control.c
  group Middlewares/JPEG
    ../../../../Middlewares_new/JPEG_ENCODE/: dct.c debug.c jcapi.c jchuff.c jcint.c jcmarker.c jutility.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/websocket
    ../../../../Middlewares_new/websocket/: base64.c hash_sha1.c websocket.c
